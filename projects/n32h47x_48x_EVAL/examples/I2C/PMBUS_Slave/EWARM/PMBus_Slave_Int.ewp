# IAR project PMBus_Slave_Int.ewp, settings and files
configuration N32H487 (ARM, debug)
  General.OGChipSelectEditMenu: N32H487ZE Nations N32H487ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H487; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h47x_48x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PMBus_Slave_Int.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H482 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H482ZE Nations N32H482ZE
  ICCARM.CCDefines: N32H482; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: I2C_Slave_Int.bin
configuration N32H475 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H475UE Nations N32H475UE
  ICCARM.CCDefines: N32H475; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: I2C_Slave_Int.bin
configuration N32H474 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H474VE Nations N32H474VE
  ICCARM.CCDefines: N32H474; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: I2C_Slave_Int.bin
configuration N32H473 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H473VE Nations N32H473VE
  ICCARM.CCDefines: N32H473; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: I2C_Slave_Int.bin
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_crc.c n32h47x_48x_dma.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_rcc.c n32h47x_48x_spi.c n32h47x_48x_usart.c
  group LOG
    ../../../../bsp/src/: delay.c log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473_EWARM.s startup_n32h474_EWARM.s startup_n32h475_EWARM.s startup_n32h482_EWARM.s startup_n32h487_EWARM.s
  group USER
    ../src/: main.c n32h47x_48x_it.c PMBusSlave.c

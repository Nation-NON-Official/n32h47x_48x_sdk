# Keil uVision project SHRTIM_LLC_HalfBridge.uvprojx, settings and files
target N32H474 (6160000::V6.16::ARMCLANG)
  device: N32H474VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SHRTIM_LLC_HalfBridge
  AfterMake: fromelf --bin --output=.\bin\SHRTIM_LLC_HalfBridge.bin .\Objects\SHRTIM_LLC_HalfBridge.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32H474, USE_STDPERIPH_DRIVER,DEBUG_TIMERC
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h474.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: n32h47x_48x_rcc.c n32h47x_48x_shrtim.c n32h47x_48x_pwr.c n32h47x_48x_gpio.c misc.c n32h47x_48x_adc.c n32h47x_48x_dac.c n32h47x_48x_dma.c n32h47x_48x_comp.c
  group USER
    ../src/: main.c n32h47x_48x_it.c n32h47x_48x_msp.c
  group DOC
    ../: readme.txt
  group BSP
    ../../../../bsp/src/: delay.c

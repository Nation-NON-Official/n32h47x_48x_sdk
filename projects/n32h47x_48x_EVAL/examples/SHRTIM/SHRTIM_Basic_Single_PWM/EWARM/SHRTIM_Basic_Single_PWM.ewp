# IAR project SHRTIM_Basic_Single_PWM.ewp, settings and files
configuration N32H474 (ARM, debug)
  General.OGChipSelectEditMenu: N32H474VE Nations N32H474VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H474; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER; ENTRY_TEST
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h47x_48x_std_periph_driver/inc; ..\..\..\..\bsp\inc; ../test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SHRTIM_Basic_Single_PWM.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: delay.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_gpio.c n32h47x_48x_rcc.c n32h47x_48x_shrtim.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473_EWARM.s startup_n32h474_EWARM.s startup_n32h475_EWARM.s startup_n32h482_EWARM.s startup_n32h487_EWARM.s
  group USER
    ../src/: main.c n32h47x_48x_it.c n32h47x_48x_msp.c

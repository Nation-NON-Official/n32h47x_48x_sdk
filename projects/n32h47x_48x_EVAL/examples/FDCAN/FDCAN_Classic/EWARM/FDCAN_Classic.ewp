# IAR project FDCAN_Classic.ewp, settings and files
configuration N32H487 (ARM, debug)
  General.OGChipSelectEditMenu: N32H487ZE Nations N32H487ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: N32H487; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h47x_48x_std_periph_driver/inc; ../../../../bsp/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H482 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H482ZE Nations N32H482ZE
  General.FPU2: 4
  ICCARM.CCDefines: N32H482; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
configuration N32H475 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H475UE Nations N32H475UE
  General.FPU2: 4
  ICCARM.CCDefines: N32H475; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: FDCAN_Classic.srec
configuration N32H474 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H474VE Nations N32H474VE
  General.FPU2: 4
  ICCARM.CCDefines: N32H474; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: FDCAN_Classic.srec
configuration N32H473 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H473VE Nations N32H473VE
  ICCARM.CCDefines: N32H473; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLIB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: n32h47x_48x_fdcan.c n32h47x_48x_gpio.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473_EWARM.s startup_n32h474_EWARM.s startup_n32h475_EWARM.s startup_n32h482_EWARM.s startup_n32h487_EWARM.s
  group USER
    ../src/: main.c n32h47x_48x_it.c

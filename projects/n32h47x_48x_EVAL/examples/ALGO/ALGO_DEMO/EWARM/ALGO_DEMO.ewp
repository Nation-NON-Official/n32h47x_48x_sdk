# IAR project ALGO_DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32H487ZE Nations N32H487ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H487; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\inc; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALGO_DEMO.bin
  ILINK.IlinkOutputFile: ALGO_DEMO.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_aes.lib; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_algo_common.lib; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_des.lib; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_hash.lib; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_rng.lib; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_sm4.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_exti.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group LOG
    ../../../../bsp/src/: delay.c log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h487_EWARM.s
  group USER
    ../src/: algo_demo.c main.c n32h47x_48x_it.c

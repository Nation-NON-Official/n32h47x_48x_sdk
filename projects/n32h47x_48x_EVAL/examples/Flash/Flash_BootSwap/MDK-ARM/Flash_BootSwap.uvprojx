# Keil uVision project Flash_BootSwap.uvprojx, settings and files
target N32H473_BOOT0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H473VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Flash_BootSwap +hex
  AfterMake: fromelf --bin --output=.\bin\Flash_BootSwap.bin .\Objects\Flash_BootSwap.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H473, USE_STDPERIPH_DRIVER,BOOT0_START
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473.s startup_n32h474.s startup_n32h475.s startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_flash.c n32h47x_48x_rcc.c n32h47x_48x_usart.c n32h47x_48x_gpio.c
  group USER
    ../src/: main.c n32h47x_48x_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
target N32H473_BOOT1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H473VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H473, USE_STDPERIPH_DRIVER,BOOT1_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H474_BOOT0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474QE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER,BOOT0_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H474_BOOT1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474QE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER,BOOT1_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H475_BOOT0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H475UE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H475, USE_STDPERIPH_DRIVER,BOOT0_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H475_BOOT1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H475UE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H475, USE_STDPERIPH_DRIVER,BOOT1_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H482_BOOT0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H482ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER,BOOT0_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H482_BOOT1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H482ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER,BOOT1_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H487_BOOT0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER,BOOT0_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H487_BOOT1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: as above
  output: Flash_BootSwap +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER,BOOT1_START
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x31000

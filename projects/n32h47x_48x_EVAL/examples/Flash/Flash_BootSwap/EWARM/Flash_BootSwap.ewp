# IAR project Flash_BootSwap.ewp, settings and files
configuration N32H487_BOOT0 (ARM, debug)
  General.OGChipSelectEditMenu: N32H487ZE Nations N32H487ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H487; BOOT0_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h47x_48x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flash_BootSwap.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: N32H47x_48x_BOOT0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H487_BOOT1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: N32H487; BOOT1_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ILINK.IlinkIcfFile: N32H47x_48x_BOOT1.icf
configuration N32H482_BOOT0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H482ZE Nations N32H482ZE
  ICCARM.CCDefines: N32H482; BOOT0_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
configuration N32H482_BOOT1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H482ZE Nations N32H482ZE
  ICCARM.CCDefines: N32H482; BOOT1_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ILINK.IlinkIcfFile: N32H47x_48x_BOOT1.icf
configuration N32H475_BOOT1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H475UE Nations N32H475UE
  ICCARM.CCDefines: N32H475; BOOT1_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ILINK.IlinkIcfFile: N32H47x_48x_BOOT1.icf
configuration N32H475_BOOT0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H475UE Nations N32H475UE
  ICCARM.CCDefines: N32H475; BOOT0_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
configuration N32H474_BOOT0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H474VE Nations N32H474VE
  ICCARM.CCDefines: N32H474; BOOT0_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
configuration N32H474_BOOT1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H474VE Nations N32H474VE
  ICCARM.CCDefines: N32H474; BOOT1_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ILINK.IlinkIcfFile: N32H47x_48x_BOOT1.icf
configuration N32H473_BOOT0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H473VE Nations N32H473VE
  ICCARM.CCDefines: N32H473; BOOT0_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
configuration N32H473_BOOT1 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H473VE Nations N32H473VE
  ICCARM.CCDefines: N32H473; BOOT1_START; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ILINK.IlinkIcfFile: N32H47x_48x_BOOT1.icf
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473_EWARM.s startup_n32h474_EWARM.s startup_n32h475_EWARM.s startup_n32h482_EWARM.s startup_n32h487_EWARM.s
  group USER
    ../src/: main.c n32h47x_48x_it.c

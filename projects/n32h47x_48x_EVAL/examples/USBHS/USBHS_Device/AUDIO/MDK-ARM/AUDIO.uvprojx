# Keil uVision project AUDIO.uvprojx, settings and files
target N32H482 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AUDIO +hex
  AfterMake: fromelf --bin --output=.\bin\AUDIO.bin .\Objects\AUDIO.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_FS
  c include: ..\inc;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\core\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\audio\inc;..\..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dbg.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_spi.c n32h47x_48x_usart.c n32h47x_48x_dma.c n32h47x_48x_i2c.c
  group USER
    ../src/: main.c n32h47x_48x_it.c usbhs_bsp.c usbd_desc.c usbd_user.c
  group n32h47x_48x_usbhs_device
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usbhs_device_driver
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/driver/src/: usbhs_core.c usbhs_dcd.c usbhs_dcd_int.c
  group usbhs_device_class
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/class/audio/src/: usbd_audio_core.c usbd_audio_out_if.c
  group Audio
    ../src/: bsp_wm8978.c
  group BSP
    ../../../../../bsp/src/: delay.c log.c
  group DOC
    ../: readme.txt
target N32H487 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: as above
  output: AUDIO +hex
  AfterMake: fromelf --bin --output=.\bin\AUDIO.bin .\Objects\AUDIO.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_FS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000

# Keil uVision project MSC_HID_Composite.uvprojx, settings and files
target N32H482 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H482ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSC_HID_Composite +hex
  AfterMake: fromelf --bin --output=.\bin\MSC_HID_Composite.bin .\Objects\MSC_HID_Composite.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_FS
  c include: ..\inc;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\core\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\msc\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\hid_msc_composite\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\customhid\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dbg.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_dma.c n32h47x_48x_sdio.c n32h47x_48x_spi.c
  group USER
    ../src/: main.c n32h47x_48x_it.c usbhs_bsp.c usbd_desc.c usbd_user.c usbd_storage.c spi_flash.c
  group n32h47x_48x_usbhs_device
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/driver/src/: usbhs_core.c usbhs_dcd.c usbhs_dcd_int.c
  group usbhs_device_driver
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/core/src/: usbd_core.c usbd_req.c usbd_ioreq.c
  group usbhs_device_class
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/class/customhid/src/: usbd_customhid_core.c
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/class/hid_msc_composite/src/: usbd_msc_hid_core.c
  group DOC
    ../: readme.txt
target N32H487 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MSC_HID_Composite +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_FS
  c include: ..\inc;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\core\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\msc\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\customhid\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\hid_msc_composite\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000

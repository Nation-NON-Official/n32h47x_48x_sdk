# Keil uVision project CDC_MSC.uvprojx, settings and files
target N32H482 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H482ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CDC +hex
  AfterMake: fromelf --bin --output=.\bin\CDC_MSC.bin .\Objects\CDC_MSC.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_FS
  c include: ..\inc;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\class\CDC\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\class\MSC\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\driver\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\core\inc;..\..\..\..\..\..\..\middlewares\fat_fs\src;..\..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dbg.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group USER
    ../src/: main.c n32h47x_48x_it.c usbhs_bsp.c usbh_user.c usbh_data.c usbh_fs.c
  group n32h47x_48x_usbhs_host
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/driver/src/: usbhs_core.c usbhs_hcd.c usbhs_hcd_int.c
  group usbhs_host_driver
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/host/core/src/: usbh_core.c usbh_ioreq.c usbh_stdreq.c usbh_hcs.c
  group usbhs_host_class
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/host/class/CDC/src/: usbh_cdc_core.c usbh_cdc_funct.c
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/host/class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FATFS
    ../../../../../../../middlewares/fat_fs/src/: ff.c
  group Log
    ../../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
target N32H487 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CDC +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_FS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000

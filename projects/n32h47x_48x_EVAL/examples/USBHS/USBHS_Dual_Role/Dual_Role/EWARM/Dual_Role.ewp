# IAR project Dual_Role.ewp, settings and files
configuration N32H487 (ARM, debug)
  General.OGChipSelectEditMenu: N32H487ZE Nations N32H487ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H487; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; USE_USB_HS_IN_FS
  ICCARM.CCIncludePath2: ../inc; ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\driver\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\core\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\class\MSC\inc; ..\..\..\..\..\bsp\inc; ..\..\..\..\..\..\..\middlewares\fat_fs\src; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\core\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\msc\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Dual_Role.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H482 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H482ZE Nations N32H482ZE
  ICCARM.CCDefines: N32H482; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; USE_USB_HS_IN_FS
  ICCARM.CCIncludePath2: ../inc; ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\driver\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\core\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\host\class\MSC\inc; ..\..\..\..\..\bsp\inc; ..\..\..\..\..\..\..\middlewares\fat_fs\src; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\class\msc\inc; ..\..\..\..\..\..\..\firmware\n32h47x_48x_usbhs_driver\device\core\inc
  group BSP
    ../../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FATFS
    ../../../../../../../middlewares/fat_fs/src/: ff.c
  group FWLB
    ../../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dma.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_spi.c n32h47x_48x_usart.c
  group usbhs_driver
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/driver/src/: usbhs_core.c usbhs_dcd.c usbhs_dcd_int.c usbhs_hcd.c usbhs_hcd_int.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h482_EWARM.s startup_n32h487_EWARM.s
  group usbhs_device_class
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group usbhs_device_core
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/device/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group usbhs_host_class
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/host/class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group usbhs_host_core
    ../../../../../../../firmware/n32h47x_48x_usbhs_driver/host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USER
    ../src/: dual_role_app.c main.c n32h47x_48x_it.c spi_flash.c usbd_desc.c usbd_storage.c usbd_user.c usbh_user.c usbhs_bsp.c

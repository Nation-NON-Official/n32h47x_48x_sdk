# Keil uVision project LCDDisplay.uvprojx, settings and files
target N32H473 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H473VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Camera +hex
  AfterMake: fromelf --bin --output=.\bin\Camera.bin .\Objects\Camera.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H47X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473.s startup_n32h474.s startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_rcc.c n32h47x_48x_gpio.c n32h47x_48x_exti.c n32h47x_48x_dma.c n32h47x_48x_femc.c n32h47x_48x_usart.c
  group USER
    ../src/: main.c n32h47x_48x_it.c lcd.c fonts.c logo1.c logo2.c
  group BSP
    ../../../../bsp/src/: log.c delay.c
  group DOC
    ../: readme.txt
target N32H474 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H473VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Camera +hex
  AfterMake: fromelf --bin --output=.\bin\Camera.bin .\Objects\Camera.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H482 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H473VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: Camera +hex
  AfterMake: fromelf --bin --output=.\bin\Camera.bin .\Objects\Camera.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H487 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: as above
  output: FEMC_LCDDisplay +hex
  AfterMake: fromelf --bin --output=.\bin\FEMC_LCDDisplay.bin .\Objects\FEMC_LCDDisplay.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000

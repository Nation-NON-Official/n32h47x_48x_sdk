# Keil uVision project Camera.uvprojx, settings and files
target N32H487 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Camera +hex
  AfterMake: fromelf --bin --output=.\bin\Camera.bin .\Objects\Camera.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2ffff
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473.s startup_n32h474.s startup_n32h475.s startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_rcc.c n32h47x_48x_gpio.c n32h47x_48x_exti.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_femc.c n32h47x_48x_usart.c
  group USER
    ../src/: main.c bsp_ov5640.c bsp_dvp.c lcd.c fonts.c logo1.c logo2.c n32h47x_48x_it.c dvp_demo.c
  group DOC
    ../: readme.txt
  group BSP
    ../../../../bsp/src/: log.c

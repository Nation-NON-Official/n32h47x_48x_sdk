# Keil uVision project PGA_UserTrimming.uvprojx, settings and files
target N32H473 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H473VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PGA_UserTrimming +hex
  AfterMake: fromelf --bin --output=.\bin\PGA_UserTrimming.bin .\Objects\PGA_UserTrimming.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H473, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h473.s startup_n32h474.s startup_n32h475.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: n32h47x_48x_rcc.c misc.c n32h47x_48x_gpio.c n32h47x_48x_pga.c n32h47x_48x_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32h47x_48x_it.c
    ../../../../bsp/src/: delay.c
  group DOC
    ../: readme.txt
target N32H474 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474VE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: PGA_UserTrimming +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H475 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H475UE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: as above
  output: PGA_UserTrimming +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H475, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
